#include <AES.h>
#include <CFB.h>

struct DecryptionTest
{
  const char *name;
  byte key[32];
  byte iv[16];
  byte ciphertext[96];
};

static DecryptionTest const AES256CFBTest = {
  "AES-256-CFB-decrypt",
  {0x37, 0x4C, 0x33, 0x53, 0x77, 0x53, 0x71, 0x61,
  0x34, 0x4D, 0x6E, 0x4D, 0x69, 0x50, 0x5A, 0x44,
  0x53, 0x55, 0x46, 0x78, 0x52, 0x79, 0x56, 0x65,
  0x74, 0x6B, 0x41, 0x63, 0x53, 0x47, 0x75, 0x4E},
  {0x50, 0x55, 0x71, 0x78, 0x33, 0x31, 0x7A, 0x36,
   0x53, 0x35, 0x61, 0x65, 0x59, 0x4B, 0x6B, 0x4E},
  {0x81, 0xF9, 0x58, 0xA4, 0xD3, 0x65, 0xAC, 0xCC, 
  0xB9, 0xBE, 0x10, 0x3E, 0x71, 0xD4, 0x94, 0x60, 
  0xAB, 0x68, 0x30, 0x04, 0x1E, 0x11, 0x94, 0x7F, 
  0xAC, 0x9B, 0x47, 0xAD, 0x0E, 0xCB, 0x5B, 0x25, 
  0x57, 0x23, 0xDF, 0x44, 0x87, 0xC3, 0x7E, 0x7E, 
  0x5A, 0x65, 0xCA, 0xE3, 0x9C, 0x1D, 0x6F, 0x31, 
  0x31, 0x91, 0x9F, 0xF2, 0x1C, 0x73, 0x4F, 0xC5, 
  0xC2, 0xCE, 0x68, 0xBC, 0x4D, 0x26, 0x09, 0xDF, 
  0xBC, 0xD5, 0xCD, 0x9B, 0xE9, 0xD4, 0xA2, 0x4C, 
  0x8F, 0xB6, 0x0D, 0x62, 0xEF, 0x58, 0x05, 0xD7, 
  0x6A, 0x7F, 0xC8, 0xDE, 0x14, 0x63, 0x47, 0x2E, 
  0xCD, 0x19, 0xA3, 0x3A, 0xF4, 0xDE, 0xEF, 0xF5}
};

CFB<AES256> cipher;

void performDecryption(const struct DecryptionTest *decryption, Cipher *cipher) {
  unsigned long start;
  unsigned long elapsed;
  byte output[96] = {0};

  printHex(decryption->ciphertext, 96);
  Serial.println();
  start = millis();
  cipher->setKey(decryption->key, cipher->keySize());
  cipher->setIV(decryption->iv, cipher->ivSize());
  cipher->decrypt((uint8_t*) output, (uint8_t*)decryption->ciphertext, sizeof(decryption->ciphertext));
  elapsed = millis() - start;
  for (short i=0; i < 96; i++) {
    Serial.print((char)output[i]);
  }
  Serial.println(); Serial.print(elapsed); Serial.print(" milliseconds \n");
}

void printHex(const uint8_t *input, size_t len) {
  for (short i=0; i < len; i++) {
    if (i % 8 == 0) {
      Serial.println();
    }
    Serial.print("0x");
    if (input[i] < 16) {
      Serial.print('0'); 
    }
    Serial.print(input[i], HEX);
    if (i+1 != len) {
      Serial.print(", ");
    }
 }
}

void setup() {
  Serial.begin(9600);
  Serial.println();
  Serial.print(AES256CFBTest.name);
  Serial.println();
  performDecryption(&AES256CFBTest, &cipher);
}

void loop() {
}
